# Keil uVision project STM32F401RCT6.uvprojx, settings and files
target STM32F401RCT6 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401RCT6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Components/BSP;../Components/Devices/LCD_ST7735;../Components/LVGL9.0;../Components/LVGL9.0/examples/porting;../Components/LVGL9.0/src;../Components/LVGL9.0/src/core;../Components/LVGL9.0/src/draw;../Components/LVGL9.0/src/draw/stm32_dma2d;../Components/LVGL9.0/src/font;../Components/LVGL9.0/src/hal;../Components/LVGL9.0/src/layouts/flex;../Components/LVGL9.0/src/layouts/grid;../Components/LVGL9.0/src/misc;../Components/LVGL9.0/src/themes/basic;../Components/LVGL9.0/src/themes/default;../Components/LVGL9.0/src/themes/mono;../Components/LVGL9.0/src/themes;../Components/LVGL9.0/examples;../Components/LVGL9.0/src/draw/sw;../Components/LVGL9.0/src/libs/barcode;../Components/LVGL9.0/src/libs/bmp;../Components/LVGL9.0/src/libs/ffmpeg;../Components/LVGL9.0/src/libs/freetype;../Components/LVGL9.0/src/libs/fsdrv;../Components/LVGL9.0/src/libs/gif;../Components/LVGL9.0/src/libs/png;../Components/LVGL9.0/src/libs/qrcode;../Components/LVGL9.0/src/libs/rlottie;../Components/LVGL9.0/src/libs/sjpg;../Components/LVGL9.0/src/libs/tiny_ttf;../Components/LVGL9.0/src/widgets/animimg;../Components/LVGL9.0/src/widgets/arc;../Components/LVGL9.0/src/widgets/bar;../Components/LVGL9.0/src/widgets/btn;../Components/LVGL9.0/src/widgets/btnmatrix;../Components/LVGL9.0/src/widgets/calendar;../Components/LVGL9.0/src/widgets/canvas;../Components/LVGL9.0/src/widgets/chart;../Components/LVGL9.0/src/widgets/checkbox;../Components/LVGL9.0/src/widgets/colorwheel;../Components/LVGL9.0/src/widgets/dropdown;../Components/LVGL9.0/src/widgets/img;../Components/LVGL9.0/src/widgets/imgbtn;../Components/LVGL9.0/src/widgets/keyboard;../Components/LVGL9.0/src/widgets/label;../Components/LVGL9.0/src/widgets/led;../Components/LVGL9.0/src/widgets/line;../Components/LVGL9.0/src/widgets/list;../Components/LVGL9.0/src/widgets/menu;../Components/LVGL9.0/src/widgets/meter;../Components/LVGL9.0/src/widgets/msgbox;../Components/LVGL9.0/src/widgets/objx_templ;../Components/LVGL9.0/src/widgets/roller;../Components/LVGL9.0/src/widgets/slider;../Components/LVGL9.0/src/widgets/span;../Components/LVGL9.0/src/widgets/spinbox;../Components/LVGL9.0/src/widgets/spinner;../Components/LVGL9.0/src/widgets/switch;../Components/LVGL9.0/src/widgets/table;../Components/LVGL9.0/src/widgets/tabview;../Components/LVGL9.0/src/widgets/textarea;../Components/LVGL9.0/src/widgets/tileview;../Components/LVGL9.0/src/widgets/win
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP
    ../Components/BSP/: BSP_GPIO.c BSP_USART.c
  group Devices
    ../Components/Devices/LCD_ST7735/: lcd.c st7735.c st7735_reg.c
  group LVGL
    ../Components/LVGL9.0/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
    ../Components/LVGL9.0/: lv_conf.h lvgl.h
  group LVGL/src
    ../Components/LVGL9.0/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Components/LVGL9.0/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_cache_builtin.c lv_img_decoder.c
    ../Components/LVGL9.0/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Components/LVGL9.0/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Components/LVGL9.0/src/layouts/flex/: lv_flex.c
    ../Components/LVGL9.0/src/layouts/grid/: lv_grid.c
    ../Components/LVGL9.0/src/libs/barcode/: code128.c lv_barcode.c
    ../Components/LVGL9.0/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Components/LVGL9.0/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Components/LVGL9.0/src/themes/basic/: lv_theme_basic.c
    ../Components/LVGL9.0/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Components/LVGL9.0/src/libs/bmp/: lv_bmp.c
    ../Components/LVGL9.0/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Components/LVGL9.0/src/libs/freetype/: lv_freetype.c lv_ftsystem.c
    ../Components/LVGL9.0/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Components/LVGL9.0/src/libs/gif/: gifdec.c lv_gif.c
    ../Components/LVGL9.0/src/libs/png/: lodepng.c lv_png.c
    ../Components/LVGL9.0/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Components/LVGL9.0/src/libs/rlottie/: lv_rlottie.c
    ../Components/LVGL9.0/src/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Components/LVGL9.0/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Components/LVGL9.0/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Components/LVGL9.0/src/widgets/animimg/: lv_animimg.c
    ../Components/LVGL9.0/src/widgets/arc/: lv_arc.c
    ../Components/LVGL9.0/src/widgets/bar/: lv_bar.c
    ../Components/LVGL9.0/src/widgets/btn/: lv_btn.c
    ../Components/LVGL9.0/src/widgets/btnmatrix/: lv_btnmatrix.c
    ../Components/LVGL9.0/src/widgets/canvas/: lv_canvas.c
    ../Components/LVGL9.0/src/widgets/chart/: lv_chart.c
    ../Components/LVGL9.0/src/widgets/checkbox/: lv_checkbox.c
    ../Components/LVGL9.0/src/widgets/colorwheel/: lv_colorwheel.c
    ../Components/LVGL9.0/src/widgets/dropdown/: lv_dropdown.c
    ../Components/LVGL9.0/src/widgets/img/: lv_img.c
    ../Components/LVGL9.0/src/widgets/imgbtn/: lv_imgbtn.c
    ../Components/LVGL9.0/src/widgets/keyboard/: lv_keyboard.c
    ../Components/LVGL9.0/src/widgets/label/: lv_label.c
    ../Components/LVGL9.0/src/widgets/led/: lv_led.c
    ../Components/LVGL9.0/src/widgets/line/: lv_line.c
    ../Components/LVGL9.0/src/widgets/list/: lv_list.c
    ../Components/LVGL9.0/src/widgets/menu/: lv_menu.c
    ../Components/LVGL9.0/src/widgets/meter/: lv_meter.c
    ../Components/LVGL9.0/src/widgets/msgbox/: lv_msgbox.c
    ../Components/LVGL9.0/src/widgets/objx_templ/: lv_objx_templ.c
    ../Components/LVGL9.0/src/widgets/roller/: lv_roller.c
    ../Components/LVGL9.0/src/widgets/slider/: lv_slider.c
    ../Components/LVGL9.0/src/widgets/span/: lv_span.c
    ../Components/LVGL9.0/src/widgets/spinner/: lv_spinner.c
    ../Components/LVGL9.0/src/widgets/spinbox/: lv_spinbox.c
    ../Components/LVGL9.0/src/widgets/switch/: lv_switch.c
    ../Components/LVGL9.0/src/widgets/table/: lv_table.c
    ../Components/LVGL9.0/src/widgets/tabview/: lv_tabview.c
    ../Components/LVGL9.0/src/widgets/textarea/: lv_textarea.c
    ../Components/LVGL9.0/src/widgets/tileview/: lv_tileview.c
    ../Components/LVGL9.0/src/widgets/win/: lv_win.c
    ../Components/LVGL9.0/src/themes/default/: lv_theme_default.c
    ../Components/LVGL9.0/src/themes/mono/: lv_theme_mono.c
software components: CMSIS:CORE 5.5.0
